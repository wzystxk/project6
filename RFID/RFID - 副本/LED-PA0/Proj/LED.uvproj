# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051C6 STMicroelectronics
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: LED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_MD,STM32F051X8
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\My_Lib\delay;..\My_Lib\LED;..\Proj
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: main.c usart.c stm32f0xx_it.c
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group My_Lib
    ../My_Lib/LED/: led.c
    ../My_Lib/delay/: delay.c
    ../User/: FM1702.c
  group System
    ../System/CMSIS/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
    ../User/: startup_stm32f0xx.s
