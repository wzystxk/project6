# Keil uVision project spi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: spi +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\user;..\stm32f051;..\drive;..\lib\src;..\lib\inc;..\lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f0xx.s
    ../stm32f051/: system_stm32f0xx.c
  group user
    ./: main.c
  group drive
    ../drive/: oled.c sys.c delay.c
  group lib
    ../lib/src/: stm32f0xx_spi.c stm32f0xx_gpio.c stm32f0xx_rcc.c
